# Repository penguin92-prg/Thrive (continued)

## KiCad design circuit/power-001-20260513/power-001-20260513.kicad_pcb (continued)

Board: 4 copper layers, 68.4 x 46.4 mm, 49 parts (38 on the bottom side), 24 nets.

File circuit/power-001-20260513/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BZ1,PKM13EPYH4000-A0,1,Buzzer,
C1,CP_Radial_D8.0mm_P3.50mm,1,470μ,
"C10, C11, C13, C5, C8",0805,5,10μ,
"C12, C2, C3",0805,3,100n,
"C6, C7, C9",0805,3,22μ,
F1,MF61NR_FUC-04,1,10A,
J1,Conn_01x02_Wire_Only,1,VIN,
J2,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,+5V_{Line},
J3,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,Power,
J4,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,Logic,
J5,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,Sub_{Power},
J6,PinHeader_1x02_P2.54mm_Horizontal,1,Sub_{Signal},
J7,PinHeader_1x05_P1.00mm_Vertical,1,ICSP_{PIC12F683},
J8,Conn_01x02_Wire_Only_SMD,1,ESC,
Q1,TSOT-23,1,BSS138,
Q2,TO-252-2,1,TJ60S04M3L,
"R10, R8",0805,2,1k,
"R11, R9",0805,2,330,
"R12, R13, R17",0805,3,1.2k,
R14,0805,1,30k,
"R15, R19, R20, R21",0805,4,10k,
R18,0805,1,100,
"R4, R5",0805,2,20k,
"R6, R7",0805,2,10,
"SW1, SW2",2MS1-T1-B4-M2-Q-E,2,SW_SPDT,
SW4,DS-850K-S-ON-K,1,Locker_SW,
"U1, U2",OKL-T6-W12N-C,2,OKL-T/6-W12N-C,
U3,TO-252-2,1,AZ1084-3.3,
U5,SOIC-8_3.9x4.9mm_P1.27mm,1,PIC12F683,
U6,SOT-223-3_TabPin2,1,LM1117MP-3.3,

## KiCad design circuit/sub-001-20260515/sub-001-20260515.kicad_pcb

Parts:
C1, C6, C7, C10, C11, C12, C13, C16, C19, C20, C23, C24, C26, C31, C32, C35, C36, C45, C46: 10μ; C_0805_2012Metric
C2, C3, C8, C9, C14, C15, C21, C22, C27, C28, C33, C34, C37, C38, C43, C44: 10n; C_0805_2012Metric
C4, C5, C17, C18, C29, C30, C39, C40: 1n; C_0805_2012Metric
C25: 10u; C_0805_2012Metric
C41, C42, C47, C48: 0.33μ; C_0805_2012Metric
D1, D2, D5, D6, D7, D8, D9, D10: IRLED; LED_D3.0mm
D3: 5V_{PWR}; LED_0603_1608Metric
D4: 3.3V_{PWR}; LED_0603_1608Metric
J1: Conn_NeoPixel; AFC01-S12FCA-00
J2: Conn_01x02_Socket; PinSocket_1x02_P2.54mm_Vertical
J3: Conn_Power; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J4: Conn_Main; AFC01-S18FCA-00
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: BSS138; SOT-23
R1, R2, R11, R12, R23, R24, R33, R34: 18k; R_0805_2012Metric
R3, R4, R13, R14, R25, R26, R37, R38: 1.5k; R_0805_2012Metric
R5, R6, R17, R18, R27, R28, R39, R40: 47; R_0805_2012Metric
R7, R8, R19, R20, R29, R30, R41, R42: 100; R_0805_2012Metric
R9, R10, R21, R22, R31, R32, R43, R44: 1k; R_0805_2012Metric
R15, R16: 330; R_0805_2012Metric
R35, R36, R45, R46: 39k; R_0805_2012Metric
R47, R48: 10k; R_0805_2012Metric
U1, U3, U6, U8, U10: NS-Tech_Grove_1x04_P2mm_Vertical
U2, U7, U11, U14, U15: LM1117GS-3.3; SOT-223-3_TabPin2
U4, U5, U12, U13, U18, U19, U22, U23: NE555DR; SOIC-8_3.9x4.9mm_P1.27mm
U9: LM1117MP-3.3; SOT-223-3_TabPin2
U16, U17: XIAO-ESP32-C3-DIP
U20, U21, U24, U25: TSSP58038; Vishay_MINICAST-3Pin
U26, U27, U28, U29: HC-SR04; PinHeader_1x04_P2.54mm_Vertical

Connections:
3.3V-unitV1: C6.1, U1.3 (VIN), U2.2 (VO)
3.3V-unitV2: C12.1, U3.3 (VIN), U7.2 (VO)
3.3V-unitV3: C20.1, U6.3 (VIN), U11.2 (VO)
3.3V-unitV4: C26.1, U8.3 (VIN), U14.2 (VO)
3.3V-unitV5: C32.1, U10.3 (VIN), U15.2 (VO)
+3.3V: C19.1, J1.9, R16.1, R47.1, R48.1, U9.2 (VO), U20.3 (Vs), U21.3 (Vs), U24.3 (Vs), U25.3 (Vs), U26.4 (VCC), U27.4 (VCC), U28.4 (VCC), U29.4 (VCC)
+5V: C1.1, C7.1, C8.1, C9.1, C10.1, C11.1, C13.1, C16.1, C21.1, C22.1, C23.1, C24.1, C25.1, C31.1, C33.1, C34.1, C35.1, C36.1, C43.1, C44.1, C45.1, C46.1, J1.10, J1.11, J1.12, J3.2, R3.2, R4.2, R5.1, R6.1, R9.1, R10.1, R13.2, R14.2, R15.1, R17.1, R18.1, R21.1, R22.1, R25.2, R26.2, R27.1, R28.1, R31.1, R32.1, R37.2, R38.2, R39.1, R40.1, R43.1, R44.1, U2.3 (VI), U4.4 (~RST), U4.8 (VCC), U5.4 (~RST), U5.8 (VCC), U7.3 (VI), U9.3 (VI), U11.3 (VI), U12.4 (~RST), U12.8 (VCC), U13.4 (~RST), U13.8 (VCC), U14.3 (VI), U15.3 (VI), U16.14 (5V), U17.14 (5V), U18.4 (~RST), U18.8 (VCC), U19.4 (~RST), U19.8 (VCC), U22.4 (~RST), U22.8 (VCC), U23.4 (~RST), U23.8 (VCC)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, D3.1 (K), D4.1 (K), J1.7, J1.8, J3.1, J4.7, J4.8, J4.9, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), Q7.3 (S), Q8.3 (S), U1.4 (GND), U2.1 (GND), U3.4 (GND), U4.1 (GND), U5.1 (GND), U6.4 (GND), U7.1 (GND), U8.4 (GND), U9.1 (GND), U10.4 (GND), U11.1 (GND), U12.1 (GND), U13.1 (GND), U14.1 (GND), U15.1 (GND), U16.13 (GND)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
IR_sig1: C41.1, R35.2, U16.1 (A0_D0)
IR_sig2: C42.1, R36.2, U16.2 (A1_D1)
IR_sig3: C47.1, R45.2, U16.3 (A2_D2)
IR_sig4: C48.1, R46.2, U16.4 (A3_D3)
unnamed: D1.2 (A), R5.2
unnamed: D1.1 (K), Q1.1 (D)
unnamed: D2.2 (A), R6.2
unnamed: D2.1 (K), Q2.1 (D)
unnamed: D3.2 (A), R15.2
unnamed: D4.2 (A), R16.2
unnamed: D5.2 (A), R17.2
unnamed: D5.1 (K), Q3.1 (D)
unnamed: D6.2 (A), R18.2
unnamed: D6.1 (K), Q4.1 (D)
unnamed: D7.2 (A), R27.2
unnamed: D7.1 (K), Q5.1 (D)
unnamed: D8.2 (A), R28.2
unnamed: D8.1 (K), Q6.1 (D)
unnamed: D9.2 (A), R39.2
unnamed: D9.1 (K), Q7.1 (D)
unnamed: D10.2 (A), R40.2
unnamed: D10.1 (K), Q8.1 (D)
unnamed: Q1.2 (G), R7.2, R9.2
unnamed: Q2.2 (G), R8.2, R10.2
unnamed: Q3.2 (G), R19.2, R21.2
unnamed: Q4.2 (G), R20.2, R22.2
unnamed: Q5.2 (G), R29.2, R31.2
unnamed: Q6.2 (G), R30.2, R32.2
unnamed: Q7.2 (G), R41.2, R43.2
unnamed: Q8.2 (G), R42.2, R44.2
unnamed: C2.1, U4.5 (CONT)
unnamed: R1.2, R3.1, U4.7 (DISCH)
unnamed: R7.1, U4.3 (OUT)
unnamed: C4.1, R1.1, U4.2 (TRIG), U4.6 (THRES)
unnamed: C3.1, U5.5 (CONT)
unnamed: R2.2, R4.1, U5.7 (DISCH)
unnamed: R8.1, U5.3 (OUT)
unnamed: C5.1, R2.1, U5.2 (TRIG), U5.6 (THRES)
unnamed: C14.1, U12.5 (CONT)
unnamed: R11.2, R13.1, U12.7 (DISCH)
unnamed: R19.1, U12.3 (OUT)
unnamed: C17.1, R11.1, U12.2 (TRIG), U12.6 (THRES)
unnamed: C15.1, U13.5 (CONT)
unnamed: R12.2, R14.1, U13.7 (DISCH)
unnamed: R20.1, U13.3 (OUT)
unnamed: C18.1, R12.1, U13.2 (TRIG), U13.6 (THRES)
unnamed: C27.1, U18.5 (CONT)
unnamed: R23.2, R25.1, U18.7 (DISCH)
unnamed: R29.1, U18.3 (OUT)
unnamed: C29.1, R23.1, U18.2 (TRIG), U18.6 (THRES)
unnamed: C28.1, U19.5 (CONT)
unnamed: R24.2, R26.1, U19.7 (DISCH)
unnamed: R30.1, U19.3 (OUT)
unnamed: C30.1, R24.1, U19.2 (TRIG), U19.6 (THRES)
unnamed: R35.1, U20.1 (OUT)
unnamed: R36.1, U21.1 (OUT)
unnamed: C37.1, U22.5 (CONT)
unnamed: R33.2, R37.1, U22.7 (DISCH)
unnamed: R41.1, U22.3 (OUT)
unnamed: C39.1, R33.1, U22.2 (TRIG), U22.6 (THRES)
unnamed: C38.1, U23.5 (CONT)
unnamed: R34.2, R38.1, U23.7 (DISCH)
unnamed: R42.1, U23.3 (OUT)
unnamed: C40.1, R34.1, U23.2 (TRIG), U23.6 (THRES)
unnamed: R45.1, U24.1 (OUT)
unnamed: R46.1, U25.1 (OUT)
RX_{teensy}-TX_{ESP32C301}: J4.6, U16.7 (TX_D6)
RX_{teensy}-TX_{ESP32C302}: J4.14, U17.7 (TX_D6)
RX_{teensy}-TX_{unitV1}: J4.15, U1.1 (TX/G34)
RX_{teensy}-TX_{unitV2}: J4.17, U3.1 (TX/G34)
RX_{teensy}-TX_{unitV3}: J4.4, U6.1 (TX/G34)
RX_{teensy}-TX_{unitV4}: J4.1, U8.1 (TX/G34)
RX_{teensy}-TX_{unitV5}: J4.10, U10.1 (TX/G34)
SCL: J1.5, U16.6 (SCL_D5)
SDA: J1.6, U16.5 (SDA_D4)
SIG_{NeoPixel}: J1.1, U17.11 (MOSI_D10)
SW_{START}: J1.2, J4.11
SW_{TCT1}: J1.4, U16.9 (SCK_D8)
SW_{TCT2}: J1.3, U16.11 (MOSI_D10)
SW_{TGL1}: J2.1, R47.2, U17.6 (SCL_D5)
SW_{TGL2}: J2.2, R48.2, U17.9 (SCK_D8)
TX_{teensy}-RX_{ESP32C301}: J4.5, U16.8 (RX_D7)
TX_{teensy}-RX_{ESP32C302}: J4.13, U17.8 (RX_D7)
TX_{teensy}-RX_{unitV1}: J4.16, U1.2 (RX/G35)
TX_{teensy}-RX_{unitV2}: J4.18, U3.2 (RX/G35)
TX_{teensy}-RX_{unitV3}: J4.3, U6.2 (RX/G35)
TX_{teensy}-RX_{unitV4}: J4.2, U8.2 (RX/G35)
TX_{teensy}-RX_{unitV5}: J4.12, U10.2 (RX/G35)
USS1: U17.1 (A0_D0), U26.2 (Echo)
USS2: U17.2 (A1_D1), U27.2 (Echo)
USS3: U17.3 (A2_D2), U28.2 (Echo)
USS4: U17.4 (A3_D3), U29.2 (Echo)
USS_{EN}: U17.5 (SDA_D4), U26.3 (Trig), U27.3 (Trig), U28.3 (Trig), U29.3 (Trig)

Notes on the sheet:
Camera
SW-SIGNAL_{PULLUP}
3-terminal regulator | 3.3V
3-terminal regulator | 3.3V | UnitV
LED
IR-LED
Connector_{Main}
USS
・D6は起動時にHIGH/LOWしてしまい、 通信していない待機時は常にHIGH ・D8はプログラムの書き込みモードにした際に HIGHになっている必要がある。 書き込みモードへの移行（Bootボタンを押しながらリセットする）を 行う場合は、プルアップ抵抗をつけておくのがベター（らしい） （GPIO8 = 0 & GPIO9 = 0 になると予期せぬ動きをする模様） ・D9はGPIO9とプルアップ抵抗、BOOTボタンに繋がっており、 BOOTボタンを押すとD9がGNDに接続してしまうため、用途は限定的 スイッチ入力に使うのがよさそう
Connector_{Power}
Connector_{NeoPixel}
IR-Receiver

Board: 2 copper layers, 114.3 x 107.0 mm, 147 parts (2 on the bottom side), 101 nets.

## KiCad design circuit/neopixel-001-20260528/neopixel-001-20260528.kicad_pcb

File circuit/neopixel-001-20260528/README.md:

# ネオピクセル基板 001

ネオピクセル基板 ver.001のREADME

## 設計者
- @penguin92-prg
- @ryo-robot14

## ピンアサイン

## 使用上の注意

## 使用部品

|No.|Ref.|Name|QTY|Assembled By|Note|URL|
|---|---|---|---|---|---|---|
|001|D1~D16|WS2812B|16|OWN|WS2812B(NeoPixel)|[秋月電子](https://akizukidenshi.com/catalog/g/g107915/)|
|002|C1~C16|Capacitor 100nF|16|JLCPCB|WS2812B用バイパスコンデンサ|[JLCPCB](https://jlcpcb.com/partdetail/YAGEO-CC0805KRX7R9BB104/C49678)|
|003|R9,10|Resister 500Ω|2|JLCPCB|WS2812B用|[JLCPCB](https://jlcpcb.com/partdetail/VikingTech-ARG05FTC5000/C2828857)|
|004|SW1,2,4|ST12-401FCG|3|OWN|タクトスイッチ・赤色LED内蔵|[秋月電子](https://akizukidenshi.com/catalog/g/g102010/)|
|005|C17,18,19|Capacitor 100nF|3|JLCPCB|スイッチ用|[JLCPCB](https://jlcpcb.com/partdetail/YAGEO-CC0805KRX7R9BB104/C49678)|
|006|R3,5,7|Resister 10kΩ|3|JLCPCB|スイッチ用|[JLCPCB](https://jlcpcb.com/partdetail/18102-0805W8F1002T5E/C17414)|
|007|R4,6,8|Resister 330Ω|3|JLCPCB|スイッチ用|[JLCPCB](https://jlcpcb.com/partdetail/18318-0805W8F3300T5E/C17630)|
|008|Q1~3|NchMOSFET|3|OWN|スイッチ用・BSS138|[秋月電子](https://akizukidenshi.com/catalog/g/g104232/)|
|009|U3~5|NOT回路 インバータ|3|OWN|スイッチ用・74AHC1G04W5|[秋月電子](https://akizukidenshi.com/catalog/g/g117602/)|
|010|U1|SSD1306|1|OWN|ディスプレイ・端を切る必要あり|[秋月電子](https://akizukidenshi.com/catalog/g/g112031/)|
|011|R1,2|Resister 1kΩ|2|JLCPCB|SSD1306用プルアップ抵抗|[JLCPCB](https://jlcpcb.com/partdetail/18201-0805W8F1001T5E/C17513)|
|012|J1|AFC01_S12FCA00|1|JLCPCB|サブ基板へのFPCコネクタ|[JLCPCB](https://jlcpcb.com/partdetail/JUSHUO-AFC01_S12FCA00/C262661)|
|013|J2|B2B-XH-A|1|OWN|キッカー基板からの48Vライン|[秋月電子](https://akizukidenshi.com/catalog/g/g112247/)|
|014|J3|B2B-XH-A|1|OWN|コンデンサ基板への48Vライン|[秋月電子](https://akizukidenshi.com/catalog/g/g112247/)|
|015|U2|Aexit Voltmeter|1|OWN|50Vまで測れる電圧計|[Amazon](https://www.amazon.co.jp/dp/B07D5W5FMP?ref=ppx_yo2ov_dt_b_fed_asin_title)|
|016|P1,3,5,7,9,11|USB Type-C Horizontal|6|OWN||[秋月電子](https://akizukidenshi.com/catalog/g/g114356)|
|017|P2,4,6,8,10,12|USB Type-C Vertical|6|JLCPCB||[JLCPCB](https://jlcpcb.com/partdetail/HanboElectronic-MC_118LDH65/C6332304)|

Board: 2 copper layers, 114.3 x 114.3 mm, 71 parts (44 on the bottom side), 72 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19: 100n; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: Conn_Sub; AFC01-S12FCA-00
J2, J3: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
P1: ESP32C3_{1}; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
P2: ESP32C3_{1}; USB_Type-C_Vertical_ C6332304
P3: ESP32C3_{2}; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
P4: ESP32C3_{2}; USB_Type-C_Vertical_ C6332304
P5: UnitV1; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
P6: UnitV1; USB_Type-C_Vertical_ C6332304
P7: UnitV2; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
P8: UnitV2; USB_Type-C_Vertical_ C6332304
P9: UnitV3; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
P10: UnitV3; USB_Type-C_Vertical_ C6332304
P11: UnitV4; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
P12: UnitV4; USB_Type-C_Vertical_ C6332304
Q1, Q2, Q3: BSS138; TSOT-23
R1, R2: 1k; R_0805_2012Metric
R3, R5, R7: 10k; R_0805_2012Metric
R4, R6, R8: 330; R_0805_2012Metric
R9, R10: 500; R_0805_2012Metric
SW1, SW2, SW4: SW_SPST_LED; ST-12-401FC-G
U1: SSD1306; SSD1306_display_module
U2: Aexit_0-50_Voltmeter
U3, U4, U5: 74AHC1G04; SOT-23-5_HandSoldering

Connections:
+3.3V: J1.4, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, U1.2 (VCC), U3.5 (VCC), U4.5 (VCC), U5.5 (VCC)
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), J1.1, J1.2, J1.3, U2.2 (V_{logic})
+48V: J2.1, J3.1, U2.1 (V_{Power})
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.1, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), J1.5, J1.6, J2.2, J3.2, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P2.A1 (GND), P3.A1 (GND), P3.A12 (GND), P3.B1 (GND), P3.B12 (GND), P4.A1 (GND), P5.A1 (GND), P5.A12 (GND), P5.B1 (GND), P5.B12 (GND), P6.A1 (GND), P7.A1 (GND), P7.A12 (GND), P7.B1 (GND), P7.B12 (GND), P8.A1 (GND), P9.A1 (GND), P9.A12 (GND), P9.B1 (GND), P9.B12 (GND), P10.A1 (GND), P11.A1 (GND), P11.A12 (GND), P11.B1 (GND), P11.B12 (GND), P12.A1 (GND), Q1.3 (S), Q2.3 (S), Q3.3 (S), R10.2, SW1.1, SW2.1, SW4.1, U1.1 (GND), U2.3 (GND), U3.3 (GND), U4.3 (GND)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
unnamed: D1.4 (DIN), R9.2
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: D16.2 (DOUT), R10.1
unnamed: Q1.1 (D), SW1.3 (K)
unnamed: Q1.2 (G), U3.4
unnamed: Q2.1 (D), SW2.3 (K)
unnamed: Q2.2 (G), U4.4
unnamed: Q3.1 (D), SW4.3 (K)
unnamed: Q3.2 (G), U5.4
unnamed: R4.1, SW1.4 (A)
unnamed: R6.1, SW2.4 (A)
unnamed: R8.1, SW4.4 (A)
P1_CC: P1.A5 (CC), P2.A5 (CC)
P1_D+: P1.A7 (D-), P2.A7 (D-)
P1_D-: P1.A6 (D+), P2.A6 (D+)
P1_SBU1: P1.A8 (SBU1), P2.A8 (SBU1)
P1_SBU2: P1.B8 (SBU2), P2.B8 (SBU2)
P1_VBUS: P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), P2.A4 (VBUS)
P2_CC: P3.A5 (CC), P4.A5 (CC)
P2_D+: P3.A7 (D-), P4.A7 (D-)
P2_D-: P3.A6 (D+), P4.A6 (D+)
P2_SBU1: P3.A8 (SBU1), P4.A8 (SBU1)
P2_SBU2: P3.B8 (SBU2), P4.B8 (SBU2)
P2_VBUS: P3.A4 (VBUS), P3.A9 (VBUS), P3.B4 (VBUS), P3.B9 (VBUS), P4.A4 (VBUS)
P3_CC: P5.A5 (CC), P6.A5 (CC)
P3_D+: P5.A7 (D-), P6.A7 (D-)
P3_D-: P5.A6 (D+), P6.A6 (D+)
P3_SBU1: P5.A8 (SBU1), P6.A8 (SBU1)
P3_SBU2: P5.B8 (SBU2), P6.B8 (SBU2)
P3_VBUS: P5.A4 (VBUS), P5.A9 (VBUS), P5.B4 (VBUS), P5.B9 (VBUS), P6.A4 (VBUS)
P4_CC: P7.A5 (CC), P8.A5 (CC)
P4_D+: P7.A7 (D-), P8.A7 (D-)
P4_D-: P7.A6 (D+), P8.A6 (D+)
P4_SBU1: P7.A8 (SBU1), P8.A8 (SBU1)
P4_SBU2: P7.B8 (SBU2), P8.B8 (SBU2)
P4_VBUS: P7.A4 (VBUS), P7.A9 (VBUS), P7.B4 (VBUS), P7.B9 (VBUS), P8.A4 (VBUS)
P5_CC: P9.A5 (CC), P10.A5 (CC)
P5_D+: P9.A7 (D-), P10.A7 (D-)
P5_D-: P9.A6 (D+), P10.A6 (D+)
P5_SBU1: P9.A8 (SBU1), P10.A8 (SBU1)
P5_SBU2: P9.B8 (SBU2), P10.B8 (SBU2)
P5_VBUS: P9.A4 (VBUS), P9.A9 (VBUS), P9.B4 (VBUS), P9.B9 (VBUS), P10.A4 (VBUS)
P6_CC: P11.A5 (CC), P12.A5 (CC)
P6_D+: P11.A7 (D-), P12.A7 (D-)
P6_D-: P11.A6 (D+), P12.A6 (D+)
P6_SBU1: P11.A8 (SBU1), P12.A8 (SBU1)
P6_SBU2: P11.B8 (SBU2), P12.B8 (SBU2)
P6_VBUS: P11.A4 (VBUS), P11.A9 (VBUS), P11.B4 (VBUS), P11.B9 (VBUS), P12.A4 (VBUS)
SCL: J1.8, R2.1, U1.3 (SCL)
SDA: J1.7, R1.1, U1.4 (SDA)
SIG_{NeoPixel}: J1.12, R9.1
SW_{START}: C19.2, J1.11, R7.1, SW4.2, U5.2
SW_{TCT1}: C17.2, J1.9, R3.1, SW1.2, U3.2
SW_{TCT2}: C18.2, J1.10, R5.1, SW2.2, U4.2

File circuit/neopixel-001-20260528/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C2, C3, C4, C5, C6, C7, C8, C9",0805,19,100n,
"D1, D10, D11, D12, D13, D14, D15, D16, D2, D3, D4, D5, D6, D7, D8, D9",LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,16,WS2812B,
J1,AFC01-S12FCA-00,1,Conn_Sub,
"J2, J3",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,2,Conn_01x02_Pin,
P1,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,ESP32C3_{1},
P10,USB_Type-C_Vertical_ C6332304,1,UnitV3,
P11,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,UnitV4,
P12,USB_Type-C_Vertical_ C6332304,1,UnitV4,
P2,USB_Type-C_Vertical_ C6332304,1,ESP32C3_{1},
P3,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,ESP32C3_{2},
P4,USB_Type-C_Vertical_ C6332304,1,ESP32C3_{2},
P5,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,UnitV1,
P6,USB_Type-C_Vertical_ C6332304,1,UnitV1,
P7,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,UnitV2,
P8,USB_Type-C_Vertical_ C6332304,1,UnitV2,
P9,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,UnitV3,
"Q1, Q2, Q3",TSOT-23,3,BSS138,
"R1, R2",0805,2,1k,
"R10, R9",0805,2,500,
"R3, R5, R7",0805,3,10k,
"R4, R6, R8",0805,3,330,
"SW1, SW2, SW4",ST-12-401FC-G,3,SW_SPST_LED,
U1,SSD1306_display_module,1,SSD1306,
U2,Aexit_0-50_Voltmeter,1,Aexit_0-50_Voltmeter,
"U3, U4, U5",SOT-23-5_HandSoldering,3,74AHC1G04,
