# Repository penguin92-prg/Thrive (continued)

## KiCad design circuit/kicker-001-20260618/kicker-001-20260618.kicad_pcb

File circuit/kicker-001-20260618/README.md:

# Kicker 001

キッカー基板 ver.001のREADME

## 設計者
- @penguin92-prg
- @ryo-robot14

## 使用上の注意

- ソレノイドが2種類あるため注意
  - 通常キック用ソレノイド「Stroke」
  - チップキック用ソレノイド「Chip」
- ワンショット回路組み込み済み
  - 1000ms程度で連続通電を回路的に遮断する
  - 過信しすぎず、まずはプログラム側での制御を！
  - ワンショット回路を使用するかどうかは基板表面のジャンパで切り替え可能
    - 2コのソレノイドそれぞれに対してONとOFFの2種のジャンパがある
    - 設定したい方のジャンパをはんだ付けして導通させること

## 使用部品

|No.|Ref.|Name|QTY|Assembled By|Note|URL|
|---|---|---|---|---|---|---|
|001|U3|XL6009E1|1|OWN|昇圧素子|[Aitendo](https://www.aitendo.com/product/10307)|
|002|Q1|BSS138|1|OWN|昇圧素子への給電EN用NMOS|[秋月電子](https://akizukidenshi.com/catalog/g/g104232)|
|003|Q2|TJ15S06M3L|1|OWN|昇圧素子への給電EN用PMOS|[秋月電子](https://akizukidenshi.com/catalog/g/g117253/)|
|004|Q4/Q5|MTB010N06RJ3|2|OWN|ソレノイドスイッチング用NMOS|[秋月電子](https://akizukidenshi.com/catalog/g/g117074/)|
|005|U2/U9/U10|TLP2361|3|OWN|フォトカプラ|[秋月電子](https://akizukidenshi.com/catalog/g/g111004/)|
|006|U1/U4/U5/U7/U8|74AHC1G04W5|5|OWN|NOTゲート（インバータ）|[秋月電子](https://akizukidenshi.com/catalog/g/g117602/)|
|007|U11/U12|74AHC1G08W5|2|OWN|ANDゲート|[秋月電子](https://akizukidenshi.com/catalog/g/g117603/)|
|008|U6|DRV8874PWPR|1|OWN|ドリブラー制御用MD|[DigiKey](https://www.digikey.jp/ja/products/detail/texas-instruments/DRV8874PWPR/11502339)|
|009|Q3|NJL7502L|1|OWN|ボール補足用フォトトランジスタ|[秋月電子](https://akizukidenshi.com/catalog/g/g102325/)|
|010|D1|OSR5JA3Z74A|1|OWN|ボール補足用LED|[秋月電子](https://akizukidenshi.com/catalog/g/g111577/)|
|011|J4|ピンヘッダ 02x05|1|OWN|供給基板との接続|[秋月電子](https://akizukidenshi.com/catalog/g/g100167/)|
|012|J1/J2/J3/J6|B2B-XH-A|4|OWN|前ドリブラー/ソレノイド-Stroke/ソレノイド-Chip/コンデンサ基板|[秋月電子](https://akizukidenshi.com/catalog/g/g112247/)|
|013|D2|CUHS20F60|1|OWN|昇圧素子用ダイオード|[秋月電子](https://akizukidenshi.com/catalog/g/g116782/)|
|014|L1|SRC1317|1|OWN|昇圧素子用インダクタ|[秋月電子](https://akizukidenshi.com/catalog/g/g116276/)|
|015|D3|OSR50603C1E|1|OWN|VCC確認用赤色LED|[秋月電子](https://akizukidenshi.com/catalog/g/g108274/)|
|016|D4|OSG50603C1E|1|OWN|LGC確認用緑色LED|[秋月電子](https://akizukidenshi.com/catalog/g/g108275/)|

Parts:
C1: 47μ; C_0805_2012Metric
C2, C6: 1μ; C_0805_2012Metric
C3, C4, C5, C11, C12: 100n; C_0805_2012Metric
C7, C8: 10μ; C_0805_2012Metric
C9: 22n; C_0805_2012Metric
C10: 220n; C_0805_2012Metric
D1: LED; LED_D3.0mm
D2: CUHS20F60
D3: PWR; LED_0603_1608Metric
D4: LGC; LED_0603_1608Metric
J1: Solenoid_{Stroke}; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Solenoid_{Chip}; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: Drribler_{Front}; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Conn_Relay; PinHeader_2x05_P2.54mm_Vertical
J6: Voltmeter; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
JP1, JP3: _{ON}; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2, JP4: _{OFF}; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 33μ; SRC1317
Q1: BSS138; TSOT-23
Q2: TJ15S06M3L; TO-252-2
Q3: Q_Photo_CE; NJL7502L
Q4, Q5: MTB010N06RJ3; TO-252-2
R1: 100; R_0805_2012Metric
R2, R3, R4, R5, R6, R13: 10k; R_0805_2012Metric
R7: 1k; R_0805_2012Metric
R8: 75; R_0805_2012Metric
R9: 36k; R_0805_2012Metric
R10, R15: 2.49k; R_0805_2012Metric
R11, R12: 100k; R_0805_2012Metric
R14: NP; R_0805_2012Metric; not fitted
R16: 330; R_0805_2012Metric
R17: 20k; R_0805_2012Metric
U1, U4, U5, U7, U8: NOT; SOT-23-5_HandSoldering
U2, U9, U10: TLP2361; SO-5-6_4.55x3.7mm_P1.27mm
U3: XL6009E1; TO-263-5_TabPin3
U6: DRV8874; HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.66x2.46mm
U11, U12: AND; SOT-23-5_HandSoldering

Connections:
+3.3V: C5.1, C11.1, C12.1, J4.9, Q3.1 (C), R8.2, R13.1, R16.1, U1.5 (VCC), U2.6 (VCC), U4.5 (VCC), U5.5 (VCC), U6.3 (SLEEP), U7.5 (VCC), U8.5 (VCC), U9.6 (VCC), U10.6 (VCC), U11.5 (VCC), U12.5 (VCC)
+48V: C6.1, D2.1 (K), J1.1, J2.2, J6.1, R9.2
BallCatch_{Front}: J4.8, Q3.2 (E), R4.1
EN_{BOOST}: J4.1, U1.2
EN_{Dribbler-Front}: J4.4, U6.1 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C11.2, C12.2, D1.2 (K), D3.1 (K), D4.1 (K), J4.2, J4.10, J6.2, Q1.2 (S), Q4.3 (S), Q5.3 (S), R2.1, R4.2, R5.2, R6.2, R7.2, R10.1, R14.2, R17.2, U1.3 (GND), U2.3 (Cathode), U2.4 (GND), U3.1 (GND), U4.3 (GND), U5.3 (GND), U6.9 (PGND), U6.15 (GND), U6.16 (PMODE), U6.17 (GND), U7.3 (GND), U8.3 (GND), U9.3 (Cathode), U9.4 (GND), U10.3 (Cathode), U10.4 (GND), U11.3 (GND), U12.3 (GND)
IMODE_{Dribbler-Front}: R17.1, U6.7 (IMODE)
Kick_{Chip}: J4.3, JP3.1 (A), JP4.1 (A), U12.1
Kick_{Stroke}: J4.7, JP1.1 (A), JP2.1 (A), U11.1
NMOS^{D}_{BOOST-Chip}: J2.1, Q5.2 (D)
NMOS^{D}_{BOOST-Stroke}: J1.2, Q4.2 (D)
unnamed: C7.1, R11.2, U7.2
unnamed: C8.1, R12.2, U8.2
unnamed: D1.1 (A), R8.1
unnamed: D2.2 (A), L1.2, U3.3 (SW)
unnamed: D3.2 (A), R15.2
unnamed: D4.2 (A), R16.2
unnamed: JP1.2 (B), R11.1
unnamed: JP3.2 (B), R12.1
unnamed: Q1.3 (D), Q2.1 (G), R3.2
unnamed: Q1.1 (G), R1.2, R2.2
unnamed: U1.4, U2.1 (Anode)
unnamed: R7.1, R9.1, U3.5 (FB)
unnamed: C9.2, U6.13 (CPH)
unnamed: C9.1, U6.14 (CPL)
unnamed: R10.2, U6.6 (IPROPI)
unnamed: C10.1, U6.12 (VCP)
unnamed: U4.4, U9.1 (Anode)
unnamed: U5.4, U10.1 (Anode)
unnamed: U7.4, U11.2
unnamed: U8.4, U12.2
OUT1_{Dribbler-Front}: J3.2, U6.8 (OUT1)
OUT2_{Dribbler-Front}: J3.1, U6.10 (OUT2)
PH_{Dribbler-Front}: J4.6, U6.2 (PH)
VCC: C10.2, J4.5, Q2.2 (D), R3.1, R15.1, U6.11 (VM)
VREF_{Dribbler-Front}: R13.2, R14.1, U6.5 (VREF)
^{ONESHOT}Kick_{Chip}: JP4.2 (B), U5.2, U12.4
^{ONESHOT}Kick_{Stroke}: JP2.2 (B), U4.2, U11.4
^{SAFE}EN_{BOOST}: R1.1, U2.5 (Vo)
^{SAFE}Kick_{Chip}: C4.1, Q5.1 (G), R6.1, U10.5 (Vo)
^{SAFE}Kick_{Stroke}: C3.1, Q4.1 (G), R5.1, U9.5 (Vo)
^{SAFE}VCC: C1.1, C2.1, L1.1, Q2.3 (S), U3.2 (EN), U3.4 (VIN)

Notes on the sheet:
BallCatch_{Front}
Connector_{Solenoid}
Connector_{Voltmeter}
t_{s} = -R_{Ω}C_{F}×ln(1-(V_{TH}/V_{H})) t_{s} = -100*10^{3}×10*10^{-6}×ln(1-(2.1/3.3)) ≒ 1.011..._{s}
EN_{BOOST}
NMOS
Protection_{EN_BOOST}
Oneshot Circuit
Protection_{Kick}
MD_{Dribbler-Front}
MOSFETのシンボルとフットプリントの連携をする際 必ずDS上のMechanicalなPinAssignとSymbolのPinAssignが 対応しているかを確認すること、しないと燃える！
LED
BOOST
Connector_{Dribbler-Front}
Connector_{Relay}

Board: 2 copper layers, 71.4 x 59.3 mm, 60 parts (34 on the bottom side), 42 nets.

File circuit/kicker-001-20260618/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0805,1,47μ,
C10,0805,1,220n,
"C11, C12, C3, C4, C5",0805,5,100n,
"C2, C6",0805,2,1μ,
"C7, C8",0805,2,10μ,
C9,0805,1,22n,
D1,LED_D3.0mm,1,LED,
D2,CUHS20F60,1,CUHS20F60,
D3,0603,1,PWR,
D4,0603,1,LGC,
J1,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Solenoid_{Stroke},
J2,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Solenoid_{Chip},
J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Drribler_{Front},
J4,PinHeader_2x05_P2.54mm_Vertical,1,Conn_Relay,
J6,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Voltmeter,
"JP1, JP3",SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,2,_{ON},
"JP2, JP4",SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,2,_{OFF},
L1,SRC1317,1,33μ,
Q1,TSOT-23,1,BSS138,
Q2,TO-252-2,1,TJ15S06M3L,
Q3,NJL7502L,1,Q_Photo_CE,
"Q4, Q5",TO-252-2,2,MTB010N06RJ3,
R1,0805,1,100,
"R10, R15",0805,2,2.49k,
"R11, R12",0805,2,100k,
"R13, R2, R3, R4, R5, R6",0805,6,10k,
R14,0805,1,NP,
R16,0805,1,330,
R17,0805,1,20k,
R7,0805,1,1k,
R8,0805,1,75,
R9,0805,1,36k,
"U1, U4, U5, U7, U8",SOT-23-5_HandSoldering,5,NOT,
"U10, U2, U9",SO-5-6_4.55x3.7mm_P1.27mm,3,TLP2361,
"U11, U12",SOT-23-5_HandSoldering,2,AND,
U3,TO-263-5_TabPin3,1,XL6009E1,
U6,HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.66x2.46mm,1,DRV8874,

## Code that names these connections

File program/offender/atmega/atmega.cpp:

#include "atmega.hpp"

namespace robot{
  void Atmega::init(){
    // INPUT & PULLUP ON
    constexpr uint8_t MASK_A =
      (1 << PA1) |
      (1 << PA2);
    DDRA  &= ~MASK_A;   // INPUT
    PORTA |=  MASK_A;   // PULLUP ON

    constexpr uint8_t MASK_B =
      (1 << PB7) |
      (1 << PB6) |
      (1 << PB5) |
      (1 << PB4) |
      (1 << PB0);
    DDRB  &= ~MASK_B;
    PORTB |=  MASK_B;

    constexpr uint8_t MASK_C =
      (1 << PC5) |
      (1 << PC4) |
      (1 << PC3) |
      (1 << PC2) |
      (1 << PC1) |
      (1 << PC0);
    DDRC  &= ~MASK_C;
    PORTC |=  MASK_C;

    constexpr uint8_t MASK_D =
      (1 << PD7);
    DDRD &= ~MASK_D;
    PORTD |= MASK_D;

    constexpr uint8_t MASK_F =
      (1 << PF2) |
      (1 << PF6) |
      (1 << PF7);
    DDRF  &= ~MASK_F;
    PORTF |=  MASK_F;

    constexpr uint8_t MASK_G =
      (1 << PG1) |
      (1 << PG0) |
      (1 << PG3);
    DDRG  &= ~MASK_G;
    PORTG |=  MASK_G;

    constexpr uint8_t MASK_H =
      (1 << PH6) |
      (1 << PH5) |
      (1 << PH4) |
      (1 << PH3) |
      (1 << PH2) |
      (1 << PH7);
    DDRH  &= ~MASK_H;
    PORTH |=  MASK_H;

    constexpr uint8_t MASK_J =
      (1 << PJ6) |
      (1 << PJ5) |
      (1 << PJ4) |
      (1 << PJ3);
    DDRJ  &= ~MASK_J;
    PORTJ |=  MASK_J;

    constexpr uint8_t MASK_L =
      (1 << PL3) |
      (1 << PL2) |
      (1 << PL1) |
      (1 << PL0);
    DDRL  &= ~MASK_L;
    PORTL |=  MASK_L;

    // LED
    for(auto p : robot::atmega::PIN_LEDs){
      pinMode(p, OUTPUT);
    }

    // Serial (With Teensy)
    Serial2.begin(115200);

    // Serial (With PC)
    Serial.begin(115200);
    Serial.println("ATmega2560 Initialization Completed!");
  }

  // Update (call this function at the end of every loop)
  void Atmega::update(){
    // Output Thresholds by PWM
    for(uint8_t i=0; i<4; i++){
      analogWrite(robot::atmega::PIN_THRESHOLDs[i], m_thresholds[i]);
    }

    // Read Registers
    uint32_t value = 0;
    uint8_t value_side = 0;

    const uint8_t a = PINA;
    const uint8_t b = PINB;
    const uint8_t c = PINC;
    const uint8_t d = PIND;
    const uint8_t f = PINF;
    const uint8_t g = PING;
    const uint8_t h = PINH;
    const uint8_t j = PINJ;
    const uint8_t l = PINL;

    value |= ((b >> PB7) & 1UL) << 0;
    value |= ((b >> PB6) & 1UL) << 1;
    value |= ((b >> PB5) & 1UL) << 2;
    value |= ((b >> PB4) & 1UL) << 3;
    value |= ((b >> PB0) & 1UL) << 4;

    value |= ((h >> PH6) & 1UL) << 5;
    value |= ((h >> PH5) & 1UL) << 6;
    value |= ((h >> PH4) & 1UL) << 7;
    value |= ((h >> PH3) & 1UL) << 8;
    value |= ((h >> PH2) & 1UL) << 9;

    value |= ((f >> PF6) & 1UL) << 10;
    value |= ((f >> PF7) & 1UL) << 11;
    value |= ((a >> PA1) & 1UL) << 12;
    value |= ((a >> PA2) & 1UL) << 13;
    value |= ((j >> PJ6) & 1UL) << 14;

    value |= ((j >> PJ5) & 1UL) << 15;
    value |= ((j >> PJ4) & 1UL) << 16;
    value |= ((j >> PJ3) & 1UL) << 17;
    value |= ((c >> PC5) & 1UL) << 18;
    value |= ((c >> PC4) & 1UL) << 19;

    value |= ((c >> PC3) & 1UL) << 20;
    value |= ((c >> PC2) & 1UL) << 21;
    value |= ((c >> PC1) & 1UL) << 22;
    value |= ((c >> PC0) & 1UL) << 23;
    value |= ((g >> PG1) & 1UL) << 24;

    value |= ((g >> PG0) & 1UL) << 25;
    value |= ((l >> PL3) & 1UL) << 26;
    value |= ((l >> PL2) & 1UL) << 27;
    value |= ((l >> PL1) & 1UL) << 28;
    value |= ((l >> PL0) & 1UL) << 29;
    
    value |= ((g >> PG3) & 1UL) << 30;
    value |= ((h >> PH7) & 1UL) << 31;

    // ========================================
    value_side |= ((f >> PF2) & 1UL) << 0;
    value_side |= ((d >> PD7) & 1UL) << 1;

    for(uint8_t i=0; i<32; i++){
      m_signals_angel[i] = (value & (1UL << i)) != 0;
    }

    for(uint8_t i=0; i<2; i++){
      m_signals_side[i] = (value_side & 1UL << i) != 0;
    }
  }

  // ========================================

  // Set Threshold
  void Atmega::setThreshold(uint8_t position, uint8_t value){
    m_thresholds[position] = value;
    return;
  }

  // Get Signals of AngelRing
  const bool (&Atmega::getLineAngel())[robot::atmega::LINE_NUM_ANGEL] {
    return m_signals_angel;
  }

  // Get Signals of Side Linesensor
  const bool (&Atmega::getLineSide())[robot::atmega::LINE_NUM_SIDE] {
    return m_signals_side;
  }
}

File program/offender/teensy/teensy.hpp:

#pragma once

#include <cstdint>
#include <array>

namespace robot{
  class Teensy{
   public:
    Teensy() = default;
    ~Teensy() = default;

    void init();
  };
}

namespace robot::pin::teensy{
  static constexpr uint8_t MOTOR_EN = 8;
  static constexpr std::array<uint8_t, 4> MOTOR_PWMs = {9, 10, 11, 12};

  static constexpr uint8_t BALLCATCH_FRONT = 26;
  static constexpr uint8_t BALLCATCH_BACK = 27;

  static constexpr uint8_t KICKER_STROKE = 30;
  static constexpr uint8_t KICKER_CHIP = 31;

  static constexpr uint8_t DRIBBLER_FRONT_EN = 22;
  static constexpr uint8_t DRIBBLER_FRONT_PH = 23;

  static constexpr uint8_t DRIBBLER_BACK = 36;

  static constexpr uint8_t LED = 33;
}

## Commit log (part)

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2026-06-24 Update ネオピク基板、メイン基板、MD基板、補足基板の回路図PDF化
2026-06-24 Update キッカー基板のボード図を完成させた、DR待ち
2026-06-24 Update キッカー基板のcommit残り
2026-06-24 Create 供給基板の回路図完成
2026-06-24 Update キッカー基板のボード図完成
2026-06-24 Update メイン基板のフォント
2026-06-24 Create JLCPCBのロゴをアップロード（png/svg）
2026-06-24 Update キッカー基板のボード図最終調整やった
2026-06-24 Create メイン基板、MD基板、キッカー基板の発注ファイルを作成
2026-06-24 Update ボール補足センサのDR完了、JLCPCBのロゴ追加
2026-06-24 Create ボール補足基板の発注ファイルを作成
2026-06-24 Update 開いたらできた
2026-06-24 Update 開いたらできちゃった
2026-06-24 Update 供給基板のプロジェクト名を修正
2026-06-24 Update キッカー基板のREADMEを整備した
2026-06-25 Update メイン基板の修正を完了させた
2026-06-25 Update メイン基板のボード図の修正commitの残り
2026-06-25 Update メイン基板の発注ファイルを更新
2026-06-25 Update 供給基板の回路図を更新
2026-06-25 Update 供給基板のDXFファイルのファイル名をRelayに変更
2026-06-25 Update サブ基板の回路図を修正した、コネクタを追加できていないので後でやる
2026-06-25 Create 昇圧用コンデンサ基板のDXFファイルを作成した
2026-06-25 Update キッカー基板とメイン基板のPDFを更新
2026-06-25 Create 昇圧用コンデンサ基板を作成
2026-06-25 Update ネオピク基板、サブ基板のDXFファイル更新
2026-06-25 Create コンデンサ基板のREADMEを作成
2026-06-25 Update コンデンサ基板のボード図を完成させた
2026-06-25 Update メイン基板に使用するFPCコネクタを変更・修正
2026-06-25 Update メイン基板修正のcommit残り
2026-06-25 Update キッカー基板のREADMEを修正
2026-06-25 Update コンデンサ基板のREADMEを整備した
2026-06-25 Update MD基板のREADMEを整備した
2026-06-25 Update メイン基板のREADMEを整備した
2026-06-25 Create 昇圧用コンデンサ基板の回路図PDFと発注データを作成
2026-06-25 Update 供給基板のボード図を進めた
2026-06-25 Update キッカー基板のボード図完成させた、DRは一日おいてから
2026-06-25 Update サブ基板更新
2026-06-25 Update commit残り
2026-06-26 Update 供給基板のDXFとボード図を更新
2026-06-26 Update MD基板のSMD部品のサイズ変更を完了した
2026-06-26 Update キッカー基板のQRコード上にあったビアを最低限にして可読性を高めた
2026-06-26 Update MD基板の発注ファイルを更新
2026-06-26 Update キッカー基板の発注ファイルを更新
2026-06-26 Update MD基板のREADMEを更新した
2026-06-26 Update 供給基板のボード図を更新
2026-06-26 Update メイン基板、MD基板、キッカー基板、昇圧用コンデンサ基板、補足センサ基板の回路図PDFとPCBPDFを更新
2026-06-26 Update キッカー基板のQRコードを修正
2026-06-26 Update メイン基板のURLを修正
2026-06-26 Update MD基板のQRコードのURLを修正した
2026-06-26 Update メイン基板とMD基板の発注ファイルとPCBPDFを更新
2026-06-26 Update キッカー基板のURLを再度修正した
2026-06-26 Update キッカー基板の発注ファイルとPCBPDFを更新
2026-06-26 Update ボール補足基板のボード図を完成させた
2026-06-26 Update キッカー基板の設計者を修正した
2026-06-26 Create ボール補足基板のREADMEを作成
2026-06-26 Update 供給基板のボード図、キッカー基板の発注ファイルを更新
2026-06-26 Update ボール補足センサの発注ファイルと3Dを出力
2026-06-26 Update サブ基板をちょっと編集
2026-06-26 Update 供給基板の3DファイルとPCBを出力
2026-06-26 Update 供給基板のPCBが完成した
2026-06-26 Update 供給基板PCBデータと3Dファイル更新
2026-06-26 Create メイン基板とサブ基板の間のFPCケーブルを作成した
2026-06-27 Create メインサブ間のFPCの発注ファイルを生成
2026-06-27 Update メインサブ間のFPCの発注ファイルを更新
2026-06-27 Create サブ基板とNeoPixel基板の間のFPCケーブルを作成した
2026-06-27 Create サブネオピク間のFPCの発注ファイルを生成
2026-06-27 Create メイン-サブのFPCケーブルのREADMEを作成
2026-06-27 Update キッカー基板のピンソケット→ピンヘッダ変更
2026-06-27 Update キッカー基板の発注ファイルを生成
2026-06-27 Update 供給基板を開いてちょっとシルクスクリーンを修正
2026-06-27 Update MD基板のピンソケット→ピンヘッダへの修正を完了させた
2026-06-27 Update メイン基板のシルクスクリーンを修正した
2026-06-27 Update 供給基板のDXFを更新
2026-06-27 Update メイン基板の回路図/ボード図/発注ファイルを更新
2026-06-27 Update サブ基板の回路図が完成した
2026-06-27 Update 供給基板のREADMEを作成
2026-06-27 Update 供給基板のボード図の修正とDR完了、再DR求
2026-06-28 Update 供給基板の回路図PDF、PCBPDF、3Dモデル、発注ファイルを生成
2026-06-28 Update キッカー基板の各種PDF、発注ファイルを更新
2026-06-28 Update メイン基板の各種PDF、3Dファイル、発注ファイルを更新
2026-06-28 Update MD基板の各種PDF、3Dファイル、発注ファイルを更新
2026-06-28 Update メイン基板のボード図を修正
2026-06-28 Update キッカー基板とMD基板の最終DRを行った
2026-06-28 Update 開いたらできちった
2026-06-28 Create ラインセンサ基板の回路図を進めた
2026-06-28 Update サブ基板とネオピク基板と電源基板のDXFファイルを更新した
2026-06-28 Update NeoPixel基板の回路図が完成
2026-06-28 Update ネオピク基板のPCBにDXFを追加
2026-06-28 Update NeoPixel基板の部品配置を開始
2026-06-28 Update ネオピク基板のDXFファイルを更新
2026-06-28 Update サブ基板のDRをちょっと進めた
2026-06-29 Update ネオピク基板の横向きUSBを配置
2026-06-29 Update サブ基板のタイマーICをNE555PからNe555DRに変更
2026-06-29 Update サブ基板の回路図のDRをした
2026-06-29 Update NeoPixel基板のPCBをちょっとだけ触った
2026-06-29 Update サブ基板の回路図を更新
2026-06-30 Update 6月の精算をした
