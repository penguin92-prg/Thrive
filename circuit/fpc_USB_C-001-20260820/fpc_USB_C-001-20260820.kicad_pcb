# Repository penguin92-prg/Thrive (continued)

## KiCad design circuit/relay-001-20260624/relay-001-20260624.kicad_pcb

Parts:
J1: Dribbler_{Back}; PinHeader_1x03_P2.54mm_Vertical
J2: Kicker-Board; PinSocket_2x05_P2.54mm_Vertical
J3: MD_{Signal}; PinSocket_2x08_P2.54mm_Horizontal
J4: Main-Board; PinSocket_2x09_P2.54mm_Vertical
J5: Power_{5V}; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J6: Power_{VCC}; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J7: Power_{Logic}; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J8: Line_{Power}; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J9: Line_{UART}; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: MD_{Power}; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J11: Motor1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J12: Motor2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J13: Motor3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J14: Motor4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J15: Voltmeter; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical

Connections:
+3.3V: J1.2, J2.9, J3.16, J4.9, J7.1
+5V: J4.12, J7.2
+5V_{Line}: J5.2, J8.2
BallCatch_{Back}: J3.2, J4.14
BallCatch_{Front}: J2.8, J4.11
Dribbler_{Back}: J1.1, J4.15
EN_{Boost}: J2.1, J4.18
EN_{Dribbler-Front}: J2.4, J4.8
GND: J1.3, J2.2, J2.10, J3.14, J4.13, J5.1, J6.1, J8.1, J10.1, J15.2
Kick_{Chip}: J2.3, J4.16
Kick_{Stroke}: J2.7, J4.17
Motor1_{PWM}: J3.10, J4.3
Motor2_{PWM}: J3.8, J4.5
Motor3_{PWM}: J3.6, J4.7
Motor4_{PWM}: J3.4, J4.10
Motor_{EN}: J3.12, J4.1
Motor_{OUT1-1}: J3.15, J11.1
Motor_{OUT1-2}: J3.13, J11.2
Motor_{OUT2-1}: J3.11, J12.1
Motor_{OUT2-2}: J3.9, J12.2
Motor_{OUT3-1}: J3.7, J13.1
Motor_{OUT3-2}: J3.5, J13.2
Motor_{OUT4-1}: J3.3, J14.1
Motor_{OUT4-2}: J3.1, J14.2
PH_{Dribbler-Front}: J2.6, J4.6
RX_{teensy}-TX_{Arduino}-5V: J4.4, J9.2
TX_{teensy}-RX_{Arduino}-5V: J4.2, J9.1
VCC: J2.5, J6.2, J10.2, J15.1

Board: 2 copper layers, 169.0 x 126.3 mm, 15 parts (0 on the bottom side), 28 nets.

File circuit/relay-001-20260624/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
J1,PinHeader_1x03_P2.54mm_Vertical,1,Dribbler_{Back},
J10,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,1,MD_{Power},
J11,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Motor1,
J12,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Motor2,
J13,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Motor3,
J14,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Motor4,
J15,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Voltmeter,
J2,PinSocket_2x05_P2.54mm_Vertical,1,Kicker-Board,
J3,PinSocket_2x08_P2.54mm_Horizontal,1,MD_{Signal},
J4,PinSocket_2x09_P2.54mm_Vertical,1,Main-Board,
J5,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,Power_{5V},
J6,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,Power_{VCC},
J7,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,Power_{Logic},
J8,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,Line_{Power},
J9,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Line_{UART},

## KiCad design circuit/main-001-20260509/main-001-20260509.kicad_pcb

File circuit/main-001-20260509/README.md:

# Main 001

メイン基板 ver.001のREADME

## 設計者
- @ryo-robot14
- @penguin92-prg

## ピンアサイン

## 使用上の注意

## 使用部品

|No.|Ref.|Name|QTY|Assembled By|Note|URL|
|---|---|---|---|---|---|---|
|001|U1|Teensy4.1|1|OWN|側面の24ピン×2に加えてSDスロット側の5ピンのうち2ピンもつける必要アリ|[PJRC](https://www.pjrc.com/store/teensy41.html)<br>[秋月電子](https://akizukidenshi.com/catalog/g/g105779/)|
|002|U2|BNO055 Module|1|OWN||[秋月電子](https://akizukidenshi.com/catalog/g/g116996/)|
|003|J1|ピンヘッダ 02x09|1|OWN|基板カッターで02x09に加工する必要がある|[秋月電子](https://akizukidenshi.com/catalog/g/g100082/)|
|004|Q1/Q2|BSS138|2|OWN|UART通信のレベル変換用|[秋月電子](https://akizukidenshi.com/catalog/g/g104232)|
|005|J2|AFC01-S18FCA-00|1|JLCPCB|サブ基板へのFPCコネクタ|[JLCPCB](https://jlcpcb.com/partdetail/JUSHUO-AFC01_S18FCA00/C262666)|
|006|BZ1|PKM13EPYH4000-A0|1|OWN|ブザー|[秋月電子](https://akizukidenshi.com/catalog/g/g104118/)|
|007|SW1|TVBP06-B043CW-B|1|OWN|白タクトスイッチ|[秋月電子](https://akizukidenshi.com/catalog/g/g108074/)|
|008|D1|OSWT1608C1A|1|OWN|青色LED(SMD)|[秋月電子](https://akizukidenshi.com/catalog/g/g103986/)|

Parts:
BZ1: Buzzer; PKM13EPYH4000-A0
C1, C2: 100n; C_0805_2012Metric
D1: D13; LED_0603_1608Metric
J1: Conn_Relay; PinHeader_2x09_P2.54mm_Vertical
J2: Conn_Sub; AFC01-S18FCA-00
Q1, Q2: BSS138; SOT-23
R1, R2, R3, R4, R8: 10k; R_0805_2012Metric
R5, R6, R7: 1k; R_0805_2012Metric
R9: 330; R_0805_2012Metric
SW1: RESET; TVBP06-B043C
U1: DEV-16771
U2: BNO055

Connections:
+3.3V: C1.1, J1.9, Q1.1 (G), Q2.1 (G), R1.1, R2.1, R5.1, R7.1, R8.1, U2.1 (VIN)
+5V: J1.12, R3.1, R4.1, U1.VIN
BallCatch_{Back}: J1.14, U1.27 (A13)
BallCatch_{Front}: J1.11, U1.26 (A12)
Buzzer: R6.2, U1.2 (OUT2)
Dribbler_{Back}: J1.15, U1.36 (CS2)
EN_{Boost}: J1.18, U1.32 (OUT1B)
EN_{Dribbler-Front}: J1.8, U1.22 (A8)
GND: BZ1.2 (-), C1.2, C2.2, D1.1 (K), J1.13, J2.10, J2.11, J2.12, SW1.2 (B), U1.GND, U2.2 (GND), U2.7 (GND)
Kick_{Chip}: J1.16, U1.31 (CTX3)
Kick_{Stroke}: J1.17, U1.30 (CRX3)
LED: R9.1, U1.33 (MCLK2)
Main_RST: C2.1, R8.2, SW1.1 (A), U1.PROGRAM
Motor1_{PWM}: J1.3, U1.9 (OUT1C)
Motor2_{PWM}: J1.5, U1.10 (CS1)
Motor3_{PWM}: J1.7, U1.11 (MOSI)
Motor4_{PWM}: J1.10, U1.12 (MISO)
Motor_{EN}: J1.1, U1.6 (OUT1D)
unnamed: BZ1.1 (+), R6.1
unnamed: D1.2 (A), R9.2
PH_{Dribbler-Front}: J1.6, U1.23 (A9)
RX_{teensy}-TX_{Arduino}-3V3: Q1.2 (S), R1.2, U1.0 (RX1)
RX_{teensy}-TX_{Arduino}-5V: J1.4, Q1.3 (D), R3.2
RX_{teensy}-TX_{ESP32C301}: J2.13, U1.7 (RX2)
RX_{teensy}-TX_{ESP32C302}: J2.5, U1.15 (A1)
RX_{teensy}-TX_{unitV1}: J2.4, U1.16 (A2)
RX_{teensy}-TX_{unitV2}: J2.2, U1.21 (A7)
RX_{teensy}-TX_{unitV3}: J2.15, U1.25 (A11)
RX_{teensy}-TX_{unitV4}: J2.18, U1.28 (RX7)
RX_{teensy}-TX_{unitV5}: J2.9, U1.34 (RX8)
SCL: R7.2, U1.19 (A5), U2.4 (SCL/R)
SDA: R5.2, U1.18 (A4), U2.3 (SDA/T)
SW_{START}: J2.8, U1.5 (IN2)
TX_{teensy}-RX_{Arduino}-3V3: Q2.2 (S), R2.2, U1.1 (TX1)
TX_{teensy}-RX_{Arduino}-5V: J1.2, Q2.3 (D), R4.2
TX_{teensy}-RX_{ESP32C301}: J2.14, U1.8 (TX2)
TX_{teensy}-RX_{ESP32C302}: J2.6, U1.14 (A0)
TX_{teensy}-RX_{unitV1}: J2.3, U1.17 (A3)
TX_{teensy}-RX_{unitV2}: J2.1, U1.20 (A6)
TX_{teensy}-RX_{unitV3}: J2.16, U1.24 (A10)
TX_{teensy}-RX_{unitV4}: J2.17, U1.29 (TX7)
TX_{teensy}-RX_{unitV5}: J2.7, U1.35 (TX8)

Notes on the sheet:
Connector_Sub
BNO055
LED
Teensy4.1
Connector_Relay
RESET_BTN
Buzzer
Level-Conversion

Board: 2 copper layers, 43.3 x 83.2 mm, 20 parts (3 on the bottom side), 42 nets.

File circuit/main-001-20260509/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BZ1,PKM13EPYH4000-A0,1,Buzzer,
"C1, C2",0805,2,100n,
D1,0603,1,D13,
J1,PinHeader_2x09_P2.54mm_Vertical,1,Conn_Relay,
J2,AFC01-S18FCA-00,1,Conn_Sub,
"Q1, Q2",SOT-23,2,BSS138,
"R1, R2, R3, R4, R8",0805,5,10k,
"R5, R6, R7",0805,3,1k,
R9,0805,1,330,
SW1,TVBP06-B043C,1,RST,
U1,DEV-16771,1,DEV-16771,
U2,BNO055,1,BNO055,

## KiCad design circuit/md-001-20260519/md-001-20260519.kicad_pcb

File circuit/md-001-20260519/README.md:

# MD 001

MD基板 ver.001のREADME

## 設計者
- @penguin92-prg
- @ryo-robot14

## 使用上の注意

## 使用部品

|No.|Ref.|Name|QTY|Assembled By|Note|URL|
|---|---|---|---|---|---|---|
|001|U1/U2/U3/U4|DRV8874PWPR|4|OWN||[DigiKey](https://www.digikey.jp/ja/products/detail/texas-instruments/DRV8874PWPR/11502339)|
|002|J1|XT30PW-F 01x02|1|OWN|供給基板からの給電|[秋月電子](https://akizukidenshi.com/catalog/g/g117948/)|
|003|J2|ピンソケット 01x03|1|OWN|ボール補足基板との接続|[秋月電子](https://akizukidenshi.com/catalog/g/g105779/)|
|004|J3|ピンヘッダ L型 02×08|1|OWN|供給基板との接続<br>基板カッターで02x08に加工する必要がある|[秋月電子](https://akizukidenshi.com/catalog/g/g100082/)|
|005|D1|OSR50603C1E|1|OWN|VCC確認用赤色LED|[秋月電子](https://akizukidenshi.com/catalog/g/g108274/)|
|006|D2|OSG50603C1E|1|OWN|LGC確認用緑色LED|[秋月電子](https://akizukidenshi.com/catalog/g/g108275/)|

Parts:
C1, C2, C5, C6: 22n; R_0805_2012Metric
C3, C4, C7, C8: 220n; R_0805_2012Metric
C9, C10, C11, C12, C13: 100n; R_0805_2012Metric
C14: 100μ; R_1206_3216Metric
D1: MTR_PWR; LED_0603_1608Metric
D2: LGC_PWR; LED_0603_1608Metric
J1: VIN-motor; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J2: Conn_Ball_Catch; PinSocket_1x03_P2.54mm_Vertical
J3: Conn_relay; PinHeader_2x08_P2.54mm_Horizontal
R1, R2, R9, R10: 10k; R_0805_2012Metric
R3, R5, R11, R13: NP; R_0805_2012Metric; not fitted
R4, R6, R12, R14: 20k; R_0805_2012Metric
R7, R8, R15, R16, R17: 2.49k; R_0805_2012Metric
R18: 330; R_0805_2012Metric
U1, U2, U3, U4: HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.66x2.46mm

Connections:
+3.3V: C9.1, C10.1, C11.1, C12.1, J2.2, J3.16, R1.1, R2.1, R9.1, R10.1, R18.1, U1.3 (SLEEP), U2.3 (SLEEP), U3.3 (SLEEP), U4.3 (SLEEP)
BallCatch_{Back}: J2.1, J3.2
GND: C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.1 (K), D2.1 (K), J1.1, J2.3, J3.14, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, U1.9 (PGND), U1.15 (GND), U1.16 (PMODE), U1.17 (GND), U2.9 (PGND), U2.15 (GND), U2.16 (PMODE), U2.17 (GND), U3.9 (PGND), U3.15 (GND), U3.16 (PMODE), U3.17 (GND), U4.9 (PGND), U4.15 (GND), U4.16 (PMODE), U4.17 (GND)
IMODE-1: R4.1, U1.7 (IMODE)
IMODE-2: R6.1, U2.7 (IMODE)
IMODE-3: R12.1, U3.7 (IMODE)
IMODE-4: R14.1, U4.7 (IMODE)
Motor1_{PWM}: J3.10, U1.2 (PH)
Motor2_{PWM}: J3.8, U2.2 (PH)
Motor3_{PWM}: J3.6, U3.2 (PH)
Motor4_{PWM}: J3.4, U4.2 (PH)
Motor_{EN}: J3.12, U1.1 (EN), U2.1 (EN), U3.1 (EN), U4.1 (EN)
Motor_{OUT1-1}: J3.15, U1.8 (OUT1)
Motor_{OUT1-2}: J3.13, U1.10 (OUT2)
Motor_{OUT2-1}: J3.11, U2.8 (OUT1)
Motor_{OUT2-2}: J3.9, U2.10 (OUT2)
Motor_{OUT3-1}: J3.7, U3.8 (OUT1)
Motor_{OUT3-2}: J3.5, U3.10 (OUT2)
Motor_{OUT4-1}: J3.3, U4.8 (OUT1)
Motor_{OUT4-2}: J3.1, U4.10 (OUT2)
unnamed: D1.2 (A), R17.2
unnamed: D2.2 (A), R18.2
unnamed: C1.2, U1.13 (CPH)
unnamed: C1.1, U1.14 (CPL)
unnamed: R7.1, U1.6 (IPROPI)
unnamed: C3.1, U1.12 (VCP)
unnamed: C2.2, U2.13 (CPH)
unnamed: C2.1, U2.14 (CPL)
unnamed: R8.1, U2.6 (IPROPI)
unnamed: C4.1, U2.12 (VCP)
unnamed: C5.2, U3.13 (CPH)
unnamed: C5.1, U3.14 (CPL)
unnamed: R15.1, U3.6 (IPROPI)
unnamed: C7.1, U3.12 (VCP)
unnamed: C6.2, U4.13 (CPH)
unnamed: C6.1, U4.14 (CPL)
unnamed: R16.1, U4.6 (IPROPI)
unnamed: C8.1, U4.12 (VCP)
VCC: C3.2, C4.2, C7.2, C8.2, C13.1, C14.1, J1.2, R17.1, U1.11 (VM), U2.11 (VM), U3.11 (VM), U4.11 (VM)
VREF-1: R1.2, R3.1, U1.5 (VREF)
VREF-2: R2.2, R5.1, U2.5 (VREF)
VREF-3: R9.2, R11.1, U3.5 (VREF)
VREF-4: R10.2, R13.1, U4.5 (VREF)

Notes on the sheet:
MD1
Connector | BallCatch
MD4
POWER INPUT
Connector | Relay
MD3
【確認事項】 ・モーター出力ピンにノイズ除去用の コンデンサ（10nF-100nF）をかませるか ・2.54mmピッチのピンソケット/ヘッダの定格電流 ＝3.0A
LED
MD2

Board: 4 copper layers, 71.4 x 21.3 mm, 41 parts (32 on the bottom side), 43 nets.

File circuit/md-001-20260519/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C5, C6",0805,4,22n,
"C10, C11, C12, C13, C9",0805,5,100n,
C14,1206,1,100μ,
"C3, C4, C7, C8",0805,4,220n,
D1,0603,1,MTR_PWR,
D2,0603,1,LGC_PWR,
J1,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,VIN-motor,
J2,PinSocket_1x03_P2.54mm_Vertical,1,Conn_Ball_Catch,
J3,PinHeader_2x08_P2.54mm_Horizontal,1,Conn_relay,
"R1, R10, R2, R9",0805,4,10k,
"R11, R13, R3, R5",0805,4,NP,
"R12, R14, R4, R6",0805,4,20k,
"R15, R16, R17, R7, R8",0805,5,2.49k,
R18,0805,1,330,
"U1, U2, U3, U4",HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.66x2.46mm,4,~,
